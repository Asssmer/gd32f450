# Keil uVision project gd32_test1.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: gd32_test1
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c include: C:\Keil_v5\Packs\GigaDevice\GD32F4xx_DFP\3.0.3\Device\F4XX\Include
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
software components: CMSIS:CORE 5.6.0, Device:Libopt 3.0.2, Device:Startup 3.0.2, Device:StdPeripherals:GPIO 3.0.2, Device:StdPeripherals:MISC 3.0.2, Device:StdPeripherals:PMU 3.0.2, Device:StdPeripherals:RCU 3.0.2
